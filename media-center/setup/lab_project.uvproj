# Keil uVision project lab_project.uvproj, settings and files
target LPC1700 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: lab_project
  c flags: Optim=1
  c include: .\common\inc;.\common\src;.\examples\USBAudio;.\examples\LCD_Blinky;.\examples\ConnectFour
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Files
    ./: startup_LPC17xx.s
    ./common/: system_LPC17xx.c
  group Source Files
    ./: ui.c GLCD_SPI_LPC1700.c KBD.c ADC.c LED.c
    ./examples/USBAudio/: adcuser.c core_cm3.c usbcore.c usbdesc.c usbdmain.c usbhw.c usbuser.c
    ./examples/LCD_Blinky/: Blinky.c
    ./examples/ConnectFour/: game.c
